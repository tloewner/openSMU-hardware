# Repository tloewner/openSMU-hardware

File README.md:

# openSMU-hardware
openSMU Hardware Repository

### Organization
This repository contains everything related to the hardware development of the openSMU project. This includes calculation, simulations, schematics and PCB/gerber files. Schematics and PCB layout is done with KiCAD, simulations with LTSpice.<br />
Submodules will be designed in a pre-development phase, before being incorporated into a functioning SMU. This allows to fix serious problems on a smaller scale and helps with keeping everything organized. Planned are three submodules: Frontend, Power Supplies and Control/Interface.<br />
At the moment, there are the following folders:<br />
+ **components_predev**: Contains Schematics/PCBs of submodules
  + **frontend**: Output Stage, V/I Measurement, DA/AD Conversion

### Currently workin on:
Layout of the frontend predev PCB is done:<br />

<br/ >
Build mostly finished, testing.

### Documentation
Will be available at some point, when i get around to it. 

### Why?
This is purely for fun, and because i'd like an SMU - don't count on anything.

## KiCad design components_predev/frontend/hardware/frontend.kicad_pcb

Schematic: frontend.sch, openSMU - Frontend

Parts:
D101: FDLL4148; D_MiniMELF; Part Number FDLL4148; Digikey FDLL4148CT-ND
K101: PE014005; Part Number PE014005; Digikey PB353-ND
P101: CONN_01X40; JST_PUD_S40B-PUDSS-1_2x20_P2.00mm_Horizontal; Part Number S40B-PUDSS-1(LF)(SN); Digikey 455-2498-ND
P102, P104: 1757268; PhoenixContact_MSTBA_2,5_4-G-5,08_1x04_P5.08mm_Horizontal; Part Number 1757268; Digikey 277-1108-ND
P103: 1757242; PhoenixContact_MSTBA_2,5_2-G-5,08_1x02_P5.08mm_Horizontal; Part Number 1757242; Digikey 277-1106-ND
Q101: SSM3K329R,LF; SOT-23; Part Number SSM3K329R,LF; Digikey SSM3K329RLFCT-ND
R101: 200m; R_1206_3216Metric; Part Number WSL1206R2000FEA; Digikey WSLC-.20CT-ND
R102: R_1206_3216Metric
R103: 68k; R_0603_1608Metric; Part Number RC0603FR-0768KL; Digikey 311-68.0KHRCT-ND

Connections:
+12V: D101.1, K101.1; also elsewhere on the board
/ADC/CNVSTA: P101.19; also elsewhere on the board
/ADC/CNVSTB: P101.20; also elsewhere on the board
/ADC/DINA: P101.13; also elsewhere on the board
/ADC/DINB: P101.14; also elsewhere on the board
/ADC/DOUTA: P101.15; also elsewhere on the board
/ADC/DOUTB: P101.16; also elsewhere on the board
/ADC/SCLK: P101.17; also elsewhere on the board
/DAC/DIN: P101.8; also elsewhere on the board
/DAC/DOUT: P101.9; also elsewhere on the board
/DAC/PD: P101.2; also elsewhere on the board
/DAC/SCLK: P101.7; also elsewhere on the board
/DAC/~BUSY: P101.1; also elsewhere on the board
/DAC/~CS: P101.6; also elsewhere on the board
/DAC/~LDAC: P101.4; also elsewhere on the board
/DAC/~READY: P101.5; also elsewhere on the board
/DAC/~RST: P101.3; also elsewhere on the board
/Inrush Current Limiter/VIn+: P102.1; also elsewhere on the board
/Inrush Current Limiter/VIn-: P102.4; also elsewhere on the board
/output_stage/disengage: P101.25; also elsewhere on the board
/supplies/v_supply: P103.1; also elsewhere on the board
/vi_filter/ih_sense+: K101.12, R101.1; also elsewhere on the board
GND: P101.18, P101.26, P101.30, P101.40, P103.2, Q101.3, R103.2; also elsewhere on the board
unnamed: D101.2, K101.2, Q101.1
RCLK: P101.39; also elsewhere on the board
SER: P101.37; also elsewhere on the board
SRCLK: P101.38; also elsewhere on the board
i_range: P101.23, Q101.2, R103.1; also elsewhere on the board
il_sense+: K101.14, R102.1; also elsewhere on the board
il_sense-: P102.2, P102.3, R101.2, R102.2; also elsewhere on the board
output: P104.3; also elsewhere on the board
pwr_enable: P101.27; also elsewhere on the board
temp: P101.11; also elsewhere on the board
v_extern: P101.24; also elsewhere on the board
v_sense-: K101.11, P104.2; also elsewhere on the board
v_sense_ext+: P104.4; also elsewhere on the board
v_sense_ext-: P104.1; also elsewhere on the board
vn: P101.32; also elsewhere on the board
vp: P101.31; also elsewhere on the board

Schematic: output_stage.sch, Output Amplifier

Parts:
C300, C301: 100n; C_1206_3216Metric; Voltage 250 V; Part Number CL31B104KEHSNNE; Digikey 1276-3084-1-ND
C303: 100n; C_0603_1608Metric; Voltage 50 V; Part Number CL10B104KB8NNNC; Digikey 1276-1000-1-ND
C304, C305: 33p; C_0805_2012Metric; Part Number CC0805JRNPOABN330; Digikey 311-4249-1-ND
D301: RED; LED_0603_1608Metric; Part Number SML-D12V1WT86; Digikey SML-D12V1WT86CT-ND
D302: FDLL4148; D_MiniMELF; Part Number FDLL4148; Digikey FDLL4148CT-ND
K301: PE014005; Part Number PE014005; Digikey PB353-ND
L301: HI1206T500R-10; L_1206_3216Metric; Part Number HI1206T500R-10; Digikey 240-2412-1-ND
Q301, Q302, Q304: MMBT5550L; SOT-23; Part Number MMBT5550L; Digikey MMBT5550LT1GOSCT-ND
Q303, Q305: MMBT5401-7-F; SOT-23; Part Number MMBT5401-7-F; Digikey MMBT5401-FDICT-ND
Q306: 2SA1962OTU; TO-3P-3_Vertical; Part Number 2SA1962OTU; Digikey 2SA1962OTU-ND
Q307: 2SC5242OTU; TO-3P-3_Vertical; Part Number 2SC5242OTU; Digikey 2SC5242OTU-ND
Q308: SSM3K329R,LF; SOT-23; Part Number SSM3K329R,LF; Digikey SSM3K329RLFCT-ND
R301: 2k; R_1206_3216Metric; Part Number ERJ-8ENF2001V; Digikey P2.00KFCT-ND
R302: 130k; R_1206_3216Metric; Part Number ERJ-8ENF1303V; Digikey P130KFCT-ND
R303: 2; R_0603_1608Metric; Part Number RL1632R-2R00-F; Digikey RL16R2.0FCT-ND
R304, R305: 120k; R_1206_3216Metric; Part Number ERJ-8ENF1203V; Digikey P120KFCT-ND
R306, R307: 100k; R_1206_3216Metric; Part Number ERJ-8ENF1003V; Digikey P100KFCT-ND
R308: 68; R_1206_3216Metric; Part Number ERJ-8ENF68R0V; Digikey P68.0FCT-ND
R309, R310: 520; R_1206_3216Metric; Part Number ERJ-8ENF5230V; Digikey P523FCT-ND
R311: 68k; R_1206_3216Metric; Part Number ERJ-8ENF6802V; Digikey P68.0KFCT-ND
R312, R313: 3k3; R_1206_3216Metric; Part Number ERJ-8ENF3321V; Digikey P3.32KFCT-ND
R314, R315: 1k; R_1206_3216Metric; Part Number ERJ-8ENF1021V; Digikey P1.02KFCT-ND
R316, R317: 200m; R_2512_6332Metric; Part Number ERJ-8BSFR20V; Digikey P17684CT-ND
R318: 68k; R_0603_1608Metric; Part Number RC0603FR-0768KL; Digikey 311-68.0KHRCT-ND
RV301: 500; Potentiometer_Bourns_3214X_Vertical; Part Number 3214X-1-501E; Mouser 652-3214X-1-501E
U301: LTC6090-5; TI_SO-PowerPAD-8; Part Number LTC6090CS8E-5#PBF; Digikey LTC6090CS8E-5#PBF-ND
U302, U303: LTC6090; TI_SO-PowerPAD-8; Part Number LTC6090CS8E#PBF; Digikey LTC6090CS8E#PBF-ND
W301, W302, W303, W304, W305: TEST_1P; TestPoint_Pad_D1.0mm

Connections:
+5V: D301.2; also elsewhere on the board
+12V: D302.1, K301.1; also elsewhere on the board
/output_stage/disengage: Q308.2, R318.1; also elsewhere on the board
/output_stage/drv_input: R301.2; also elsewhere on the board
GND: C300.1, C301.1, Q308.3, R318.2, U301.1, U302.1, U302.7, U303.1, U303.4, U303.9; also elsewhere on the board
unnamed: C303.1, Q301.2, R308.1, R309.1, R312.2, W304.1
unnamed: C303.2, Q301.3, R310.2, R311.1, R313.2
unnamed: C304.1, Q302.1, Q304.2, R312.1
unnamed: C305.2, Q303.1, Q305.2, R313.1
unnamed: D301.1, R303.2
unnamed: D302.2, K301.2, Q308.1
unnamed: K301.11, Q304.3, Q305.3, R316.2, R317.1, W305.1
unnamed: K301.12, L301.2
unnamed: Q301.1, RV301.2
unnamed: Q302.2, Q306.1, R314.2
unnamed: Q302.3, Q304.1, Q306.2, R316.1
unnamed: Q303.2, Q307.1, R315.1
unnamed: Q303.3, Q305.1, Q307.2, R317.2
unnamed: R301.1, R302.2, U301.2
unnamed: R304.1, R307.2, U302.3
unnamed: R304.2, R305.1, R308.2, U301.6, W303.1
unnamed: R305.2, R306.1, U303.3
unnamed: R309.2, RV301.1
unnamed: R310.1, RV301.3
unnamed: U301.4, U301.9, U302.2, U302.6, W301.1
unnamed: U301.7, U303.2, U303.6, W302.1
VDD: C301.2, Q306.3, R306.2, R314.1, U303.7; also elsewhere on the board
VSS: C300.2, Q307.3, R307.1, R311.2, R315.2, U302.4, U302.9; also elsewhere on the board
il_sense-: C304.2, C305.1; also elsewhere on the board
output: L301.1, R302.1; also elsewhere on the board
temp: R303.1, U301.5, U301.8, U302.5, U302.8, U303.5, U303.8; also elsewhere on the board
v_ref_2: U301.3; also elsewhere on the board

Schematic: supplies.sch, Power Supplies

Parts:
C402, C407, C418, C419, C423, C424, C426: 22u; CP_Elec_4x3; Voltage 16 V; Part Number 865080340003; Digikey 732-8413-1-ND
C403, C404, C408, C412, C416, C417, C421, C422, C425: 100n; C_0603_1608Metric; Voltage 16V; Part Number CL10B104K08NNNC; Digikey 1276-1005-1-ND
C405, C409, C413, C414, C420: C_Small; C_0603_1608Metric
C406, C415: 4n7; C_0603_1608Metric
C410: 4u7; C_0603_1608Metric; Voltage 16 V; Part Number CL10A475KO8NNNC; Digikey 1276-1784-1-ND
D401, D402, D403, D404: GREEN; LED_0603_1608Metric; Part Number SML-D12M1WT86; Digikey SML-D12M1WT86CT-ND
D405, D407, D408: NSR0530HT1G; D_SOD-323; Part Number NSR0530HT1G; Digikey NSR0530HT1GOSCT-ND
D406: UDZ4V7B-7; D_SOD-323; Part Number UDZ4V7B-7; Digikey UDZ4V7B-7DICT-ND
L401: Ferrite_Bead; L_0603_1608Metric; Part Number 742792609; Digikey 732-1591-1-ND
L402, L404: 22u; L_Bourns-SRN6028; Part Number NR6028T220M; Digikey 587-2103-1-ND
L403, L405: 330u; L_Bourns-SRN6028; Part Number TYS6045331M-10; Digikey 240-2744-1-ND
P401, P402, P403, P404: CONN_01X02; PinHeader_1x02_P2.54mm_Vertical; Part Number M20-9990246; Digikey 952-2262-ND
R401: 990; R_0603_1608Metric
R402: 120; R_0603_1608Metric
R403, R405, R408, R409, R410, R411, R413, R414, R415: R_Small; R_0603_1608Metric
R404, R406: 290; R_0603_1608Metric
R407: 1k5; R_0603_1608Metric
R412: 62k; R_0603_1608Metric
U401, U403: AOZ1284; TI_SO-PowerPAD-8; Part Number AOZ1284PI; Digikey 785-1689-1-ND
U402: LT1617; SOT-23-5; Part Number LT1617ES5#TRMPBF; Digikey LT1617ES5#TRMPBFCT-ND
U404: MIC39100; SOT-223; Part Number MIC39100-5.0WS; Digikey 576-1173-ND
U405: MC79M05; TO-252-2; Part Number MC79M05CDTRKG; Digikey MC79M05CDTRKGOSCT-ND
W401, W402, W403, W404: TEST_1P; TestPoint_Pad_D1.0mm

Connections:
+3V3: D402.2, P404.2, W402.1; also elsewhere on the board
+5V: D403.2, P402.2, W403.1; also elsewhere on the board
+12V: C402.1, C403.1, C404.1, C412.1, D401.2, L402.1, P401.1, R407.1, U401.9, U402.5, U403.9, W401.1; also elsewhere on the board
-5V: D404.1, P403.2, W404.1; also elsewhere on the board
/supplies/v_supply: L401.2; also elsewhere on the board
GND: C402.2, C403.2, C404.2, C405.2, C406.2, C407.2, C408.2, C412.2, C414.2, C415.2, C416.2, C417.2, C418.2, C419.2, C421.2, C422.2, C423.2, C424.1, C425.2, C426.2, D405.1, D406.2, D407.2, D408.2, R401.2, R402.2, R403.2, R404.2, R406.2, R409.2, R411.2, R412.2, R415.2, U401.3, U402.2, U403.3, U404.2, U404.4, U405.1; also elsewhere on the board
unnamed: C405.1, R405.2
unnamed: C406.1, U401.7
unnamed: C407.1, C408.1, L401.1, P401.2
unnamed: C409.1, D407.1, L403.1, U401.1
unnamed: C409.2, U401.2
unnamed: C410.1, D405.2, L404.1
unnamed: C410.2, L402.2, U402.1
unnamed: C413.1, C416.1, C418.1, L404.2, R410.1, U405.2
unnamed: C413.2, R410.2, R411.1, U402.3
unnamed: C414.1, R413.2
unnamed: C415.1, U403.7
unnamed: C417.1, C419.1, L403.2, R408.1, U404.1
unnamed: C420.1, D408.1, L405.1, U403.1
unnamed: C420.2, U403.2
unnamed: C421.1, C423.1, P402.1, U404.3
unnamed: C422.1, C424.2, P403.1, U405.3
unnamed: C425.1, C426.1, L405.2, P404.1, R414.1
unnamed: D401.1, R401.1
unnamed: D402.1, R402.1
unnamed: D403.1, R404.1
unnamed: D404.2, R406.1
unnamed: R403.1, U401.4
unnamed: R405.1, U401.5
unnamed: R408.2, R409.1, U401.6
unnamed: R412.1, U403.4
unnamed: R413.1, U403.5
unnamed: R414.2, R415.1, U403.6
rails_en: D406.1, R407.2, U401.8, U402.4, U403.8

Notes on the sheet:
-6V
all LEDs 10 mA each
f_sw = 746 kHz

Schematic: vi_filter.sch, Voltage/Current Measurement Switching/Filtering

Parts:
C501, C502, C503, C504, C505, C506, C512, C513, C518, C521, C522, C523, C524: 100n; C_0603_1608Metric; Voltage 16V; Part Number CL10B104K08NNNC; Digikey 1276-1005-1-ND
C507, C508, C509, C510, C511, C514, C515, C516, C517, C519, C520: C_Small; C_0603_1608Metric
D501, D502: FDLL4148; D_MiniMELF; Part Number FDLL4148; Digikey FDLL4148CT-ND
K501, K502, K503: HE3621A1200; HE3600; Part Number HE3621A1200; Digikey HE208-ND
K504, K505: EC2-12NU; Kemet_EC2-12NU-L; Part Number EC2-12NU; Digikey 399-11029-5-ND
L501, L502, L503, L504, L505, L506, L507, L508, L509, L510, L511, L512, L513, L514, L515, L516, L517, L518, L519, L520: L_Small; L_0603_1608Metric
Q501, Q502, Q503, Q504, Q505: SSM3K329R,LF; SOT-23; Part Number SSM3K329R,LF; Digikey SSM3K329RLFCT-ND
R501, R502, R503, R504, R505, R506, R507, R508, R509, R510: R_Small; R_0603_1608Metric
R511, R512, R514, R515, R516: 68k; R_0603_1608Metric; Part Number RC0603FR-0768KL; Digikey 311-68.0KHRCT-ND
R513: 1776-C6217; 1776-C62; Part Number 1776-C681; Digikey 1776-C681-ND
U406, U407, U408, U409: SN74LVC1G373; SOT-363_SC-70-6; Part Number SN74LVC1G373DCKR; Digikey 296-18775-1-ND
U410, U502: 74HC595; TSSOP-16_4.4x5mm_P0.65mm; Part Number 74HC595PW,112; Digikey 1727-6439-ND
U501, U503, U506, U507: ISL2863x; TSSOP-14_4.4x5mm_P0.65mm; Part Number ISL28633FVZ-T7A; Digikey ISL28633FVZ-T7ACT-ND
U504: TPS73001; SOT-23-6; Part Number TPS73001DBVR; Digikey 296-27055-1-ND
U505: MIC5270YM5; SOT-23-5; Part Number MIC5270YM5-TR; Digikey 576-1295-2-ND

Connections:
+3V3: C501.2, U410.10, U410.16, U502.10, U502.16; also elsewhere on the board
+4.2V: C502.1, C503.1, C513.1, C518.1, C522.1, R504.1, U406.1, U406.5, U407.1, U407.5, U408.1, U408.5, U409.1, U409.5, U501.14, U503.14, U504.6, U506.14, U507.14
+5V: C506.1, K501.2, K502.2, K503.2, U504.1, U504.3; also elsewhere on the board
+12V: D501.1, D502.1, K504.12, K505.12; also elsewhere on the board
-1.5V: C504.1, C505.1, C521.1, C523.1, C524.1, R506.1, U406.2, U407.2, U408.2, U409.2, U501.7, U503.7, U505.4, U506.1, U506.2, U506.7, U507.1, U507.2, U507.7
-5V: C512.1, U505.5; also elsewhere on the board
/ADC/i_meas+: U503.12; also elsewhere on the board
/ADC/i_meas-: U503.10; also elsewhere on the board
/ADC/v_meas+: U501.12; also elsewhere on the board
/ADC/v_meas-: U501.10; also elsewhere on the board
/vi_filter/ih_sense+: K505.10; also elsewhere on the board
B0: Q501.2, R511.1, U502.15
B1: Q502.2, R512.1, U502.1
B2: Q503.2, R514.1, U502.2
B3: U406.3, U502.3
B4: U406.6, U502.4
B5: U407.3, U502.5
B6: U407.6, U502.6
B7: U408.3, U502.7
B8: U408.6, U410.15
B9: U409.3, U410.1
B10: U409.6, U410.2
B11: U410.3
B12: U410.4
B13: U410.5
B14: U410.6
B15: U410.7
GND: C501.1, C502.2, C503.2, C504.2, C505.2, C506.2, C509.2, C512.2, C513.2, C518.2, C521.2, C522.2, C523.2, C524.2, Q501.3, Q502.3, Q503.3, Q504.3, Q505.3, R503.2, R505.2, R511.2, R512.2, R514.2, R515.2, R516.2, U410.8, U410.13, U502.8, U502.13, U504.2, U505.2; also elsewhere on the board
L1: K503.3, Q501.1
L2: K502.3, Q502.1
L3: K501.3, Q503.1
unnamed: C507.1, L501.1, R501.1, U501.4
unnamed: C507.2, L502.2, R501.2, U501.5
unnamed: C508.1, L503.1, R502.1, U503.4
unnamed: C508.2, L504.2, R502.2, U503.5
unnamed: C509.1, U504.4
unnamed: C510.1, L501.2, L505.1
unnamed: C510.2, L502.1, L506.2
unnamed: C511.1, L503.2, L507.1
unnamed: C511.2, L504.1, L508.2
unnamed: C514.1, L505.2, L509.1
unnamed: C514.2, L506.1, L510.2
unnamed: C515.1, L507.2, L511.1
unnamed: C515.2, L508.1, L512.2
unnamed: C516.1, L509.2, L513.1
unnamed: C516.2, L510.1, L514.2
unnamed: C517.1, L511.2, L515.1
unnamed: C517.2, L512.1, L516.2
unnamed: C519.1, L513.2, L517.1
unnamed: C519.2, L514.1, L518.2
unnamed: C520.1, L515.2, L519.1
unnamed: C520.2, L516.1, L520.2
unnamed: D501.2, K504.1, Q504.1
unnamed: D502.2, K505.1, Q505.1
unnamed: K501.1, K502.1, K503.1, U507.4
unnamed: K501.4, K504.9, R513.1
unnamed: K502.4, R513.2
unnamed: K503.4, R513.3
unnamed: K504.4, R513.6, U507.5
unnamed: K505.4, U506.5
unnamed: K505.9, U506.4
unnamed: L517.2, R507.2
unnamed: L518.1, R508.2
unnamed: L519.2, R509.2
unnamed: L520.1, R510.2
unnamed: R503.1, R504.2, U504.5
unnamed: R505.1, R506.2, U505.3
unnamed: R507.1, U507.12
unnamed: R508.1, U507.10
unnamed: R509.1, U506.12
unnamed: R510.1, U506.10
unnamed: U406.4, U503.1
unnamed: U407.4, U503.2
unnamed: U408.4, U501.1
unnamed: U409.4, U501.2
unnamed: U410.14, U502.9
RCLK: U410.12, U502.12; also elsewhere on the board
SER: U502.14; also elsewhere on the board
SRCLK: U410.11, U502.11; also elsewhere on the board
i_range: Q505.2, R516.1; also elsewhere on the board
il_sense+: K505.8; also elsewhere on the board
il_sense-: K505.3, K505.5; also elsewhere on the board
output: K504.10; also elsewhere on the board
v_extern: Q504.2, R515.1; also elsewhere on the board
v_ref_2: U501.11, U503.11, U506.11, U507.11; also elsewhere on the board
v_sense-: K504.3; also elsewhere on the board
v_sense_ext+: K504.8; also elsewhere on the board
v_sense_ext-: K504.5; also elsewhere on the board

Schematic: DAC.sch, Digital-Analog Converter

Parts:
C601, C603, C605: 10u; C_0603_1608Metric; Voltage 25 V; Part Number GRM188R61E106MA73D; Digikey 490-7202-1-ND
C602, C604, C606, C608: 100n; C_0603_1608Metric; Voltage 16V; Part Number CL10B104K08NNNC; Digikey 1276-1005-1-ND
C607: 22u; C_0603_1608Metric; Part Number GRM188R61A226ME15D; Digikey 490-10476-1-ND
J601: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
JP601, JP602: Jumper_NC_Dual; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm
R517, R518, R519, R520, R521, R522, R523, R524, R525, R526, R527: 22; R_0603_1608Metric; Part Number RC0603FR-0722RL; Digikey 311-22.0HRCT-ND
R601, R602: 2k; R_0603_1608Metric; Part Number ERJ-3EKF2001V; Digikey P2.00KHCT-ND
U601: MAX5318; TSSOP-24_4.4x7.8mm_P0.65mm; Part Number MAX5318GUG+; Digikey MAX5318GUG+-ND

Connections:
+3V3: C601.1, C602.1, JP601.3, JP602.3, R601.2, R602.1, U601.24; also elsewhere on the board
+5V: C603.2, C604.2, C605.2, C606.2, U601.14, U601.21; also elsewhere on the board
/DAC/DIN: R526.2; also elsewhere on the board
/DAC/DOUT: R527.2; also elsewhere on the board
/DAC/PD: R523.2; also elsewhere on the board
/DAC/SCLK: R525.2; also elsewhere on the board
/DAC/~BUSY: R520.2; also elsewhere on the board
/DAC/~CS: R524.2; also elsewhere on the board
/DAC/~LDAC: R518.2; also elsewhere on the board
/DAC/~READY: R519.2; also elsewhere on the board
/DAC/~RST: R517.2, R601.1; also elsewhere on the board
/output_stage/drv_input: J601.2; also elsewhere on the board
GND: C601.2, C602.2, C603.1, C604.1, C605.1, C606.1, C607.1, C608.1, J601.3, JP601.1, JP602.1, U601.13, U601.19, U601.20, U601.23; also elsewhere on the board
unnamed: C607.2, C608.2, U601.22
unnamed: J601.1, U601.15, U601.16
unnamed: JP601.2, R522.2
unnamed: JP602.2, R521.2
unnamed: R517.1, U601.1
unnamed: R518.1, U601.5
unnamed: R519.1, U601.2
unnamed: R520.1, R602.2, U601.4
unnamed: R521.1, U601.3
unnamed: R522.1, U601.10
unnamed: R523.1, U601.11
unnamed: R524.1, U601.9
unnamed: R525.1, U601.8
unnamed: R526.1, U601.7
unnamed: R527.1, U601.6
v_ref: U601.18; also elsewhere on the board

Schematic: ADC.sch, Analog-Digital Converter, Reference Voltage

Parts:
C701, C723: 22u; CP_Elec_4x3; Voltage 16 V; Part Number 865080340003; Digikey 732-8413-1-ND
C702, C704, C706, C709, C710, C711, C715, C716, C722: 100n; C_0603_1608Metric; Voltage 16V; Part Number CL10B104K08NNNC; Digikey 1276-1005-1-ND
C703, C705, C707, C708, C717: 10u; C_0603_1608Metric; Voltage 25 V; Part Number GRM188R61E106MA73D; Digikey 490-7202-1-ND
C713, C714: 220u; C_1206_3216Metric; Voltage 6.3 V; Part Number GRM31CR60J227ME11L; Digikey 490-13970-1-ND
C718, C719, C720, C721: 10u; C_0805_2012Metric; Voltage 10 V; Part Number CL21A106KPFNNNG; Digikey 1276-6456-1-ND
C724: C_Small; C_0603_1608Metric
L701, L702: 10u; L_0805_2012Metric; Part Number LBR2012T100K; Digikey 587-2045-1-ND
Q701: SSM3K329R,LF; SOT-23; Part Number SSM3K329R,LF; Digikey SSM3K329RLFCT-ND
R603, R604, R605, R606, R607, R608, R609: 22; R_0603_1608Metric; Part Number RC0603FR-0722RL; Digikey 311-22.0HRCT-ND
R701: 10k; R_0603_1608Metric; Part Number RC0603FR-0710KL; Digikey 311-10.KHRCT-ND
R702, R706, R707: R_Small; R_0603_1608Metric
R703: 143; R_1206_3216Metric; Part Number CRCW1206143RFKEA; Digikey 541-143FCT-ND
R704, R705: 1k; R_0603_1608Metric
R708, R709: 10k; R_0603_1608Metric; Part Number P10KDBCT-ND; Digikey P10KDBCT-ND
RV701: 10k; Potentiometer_Bourns_3214X_Vertical; Part Number 3214X-1-103E; Digikey 3214X-1-103ECT-ND
U701: MIC7211; SOT-23-6; Part Number MIC7211YM5-TR; Digikey 576-1318-1-ND
U702: ADR4533; SOIC-8_3.9x4.9mm_P1.27mm; Part Number ADR4533ARZ; Digikey ADR4533ARZ-ND
U703: LMT88; SOT-353_SC-70-5; Part Number LMT88DCKR; Digikey 296-38167-1-ND
U704, U705: NCP508; SOT-353_SC-70-5; Part Number NCP508SQ18T1G; Digikey NCP508SQ18T1GOSCT-ND
U706: MAX11960; QFN-32-1EP_5x5mm_P0.5mm_EP3.45x3.45mm; Part Number MAX11960ETJ+; Digikey MAX11960ETJ+-ND
U707: LTC2055; TSSOP-8_3x3mm_P0.65mm; Part Number LTC2055CMS8#PBF; Digikey LTC2055CMS8#PBF-ND
U708: TPS73001; SOT-23-6; Part Number TPS73001DBVR; Digikey 296-27055-1-ND
W701, W702, W703, W704, W705, W706, W707: TEST_1P; TestPoint_Pad_D1.0mm

Connections:
+3V3: C701.1, C702.1, L702.1, U704.1, U704.3, U705.1, U705.3; also elsewhere on the board
+5V: C704.2, C706.1, C715.1, C722.1, C723.1, L701.1, R702.1, U701.2, U703.4, U707.8, U708.1, U708.3; also elsewhere on the board
+12V: R703.1; also elsewhere on the board
/ADC/CNVSTA: R605.2; also elsewhere on the board
/ADC/CNVSTB: R609.2; also elsewhere on the board
/ADC/DINA: R604.2; also elsewhere on the board
/ADC/DINB: R608.2; also elsewhere on the board
/ADC/DOUTA: R603.2; also elsewhere on the board
/ADC/DOUTB: R607.2; also elsewhere on the board
/ADC/SCLK: R606.2; also elsewhere on the board
/ADC/i_meas+: U706.32; also elsewhere on the board
/ADC/i_meas-: U706.31; also elsewhere on the board
/ADC/v_meas+: U706.2; also elsewhere on the board
/ADC/v_meas-: U706.1; also elsewhere on the board
GND: C701.2, C702.2, C703.1, C704.1, C705.1, C706.2, C707.2, C708.2, C709.1, C710.2, C711.2, C714.2, C715.2, C716.2, C717.2, C718.1, C719.1, C720.1, C721.1, C722.2, C723.2, C724.2, Q701.3, R701.2, R707.2, R709.2, RV701.3, U701.5, U702.4, U703.2, U703.5, U704.2, U705.2, U706.3, U706.8, U706.16, U706.19, U706.20, U706.28, U706.29, U706.30, U706.33, U707.4, U708.2; also elsewhere on the board
unnamed: C703.2, L701.2, U702.2
unnamed: C705.2, C709.2, L702.2, U706.4, U706.5, W703.1
unnamed: C707.1, C710.1, U704.5, U706.21, U706.22, W705.1
unnamed: C708.1, C711.1, U705.5, U706.9, U706.10, W704.1
unnamed: C713.1, R704.2, U707.3, W702.1
unnamed: C713.2, C714.1, R705.2
unnamed: C716.1, C717.1, R706.2, U706.17, U706.18, U708.6, W706.1
unnamed: C718.2, U706.24
unnamed: C719.2, U706.26
unnamed: C720.2, U706.25
unnamed: C721.2, U706.27
unnamed: C724.1, U708.4
unnamed: Q701.1, R703.2
unnamed: Q701.2, R701.1, U701.1
unnamed: R603.1, U706.7
unnamed: R604.1, U706.15
unnamed: R605.1, U706.13
unnamed: R606.1, U706.11
unnamed: R607.1, U706.6
unnamed: R608.1, U706.14
unnamed: R609.1, U706.12
unnamed: R702.2, RV701.1
unnamed: R704.1, R705.1, U702.6, W701.1
unnamed: R706.1, R707.1, U708.5
unnamed: R708.2, R709.1, U707.6
unnamed: RV701.2, U701.3
unnamed: U701.4, U703.3
v_ref: R708.1, U706.23, U707.1, U707.2, W707.1; also elsewhere on the board
v_ref_2: U707.5, U707.7; also elsewhere on the board

Notes on the sheet:
V_ref = 3.3V V_ref_2 = 1.65V
1.8V
3.6V
Heater

Schematic: inrush_limiter.sch, Inrush Current Limit

Parts:
C201, C202: 100u; CP_Radial_D10.0mm_P5.00mm; Part Number UVR2C101MHD; Digikey 493-1165-ND
C712, C725: C_Small; C_0603_1608Metric
D201, D202: 10V; D_SOD-323; Part Number MM3Z10VST1G; Digikey MM3Z10VST1GOSCT-ND
NT701: Net-Tie_2; NetTie-2_SMD_Pad0.5mm
Q203, Q204: MMBT5550L; SOT-23; Part Number MMBT5550L; Digikey MMBT5550LT1GOSCT-ND
Q702: FDMS86255; TDSON-8-1; Part Number FDMS86255; Digikey FDMS86255CT-ND
Q703: FQB12P20; TO-252-2; Part Number FQB12P20TM; Digikey FQB12P20TMCT-ND
R201, R202: 18k; R_0603_1608Metric
R203, R204: 220; R_1206_3216Metric; Part Number RC0603FR-07220RL; Digikey 311-220HRCT-ND
R205, R206, R207, R208: 68k; R_0603_1608Metric; Part Number RC0603FR-0768KL; Digikey 311-68.0KHRCT-ND
R211, R212, R213, R214: R_Small; R_0603_1608Metric
W201, W202: TEST_1P; TestPoint_Pad_D1.0mm

Connections:
/Inrush Current Limiter/VIn+: D201.1, Q703.3, R201.2, R203.2; also elsewhere on the board
/Inrush Current Limiter/VIn-: D202.2, Q702.1 (S), Q702.2 (S), Q702.3 (S), R202.2, R204.2; also elsewhere on the board
GND: C712.2, C725.1, NT701.2, R212.2, R214.2; also elsewhere on the board
unnamed: D201.2, Q703.1, R201.1, R207.2
unnamed: D202.1, Q702.4 (G), R202.1, R208.2
unnamed: Q203.1, R205.1
unnamed: Q203.2, R207.1
unnamed: Q204.1, R206.1
unnamed: Q204.2, R208.1
VDD: C201.1, Q703.2, R203.1, R211.1, W201.1; also elsewhere on the board
VSS: C202.2, Q702.5 (D), R204.1, R213.1, W202.1; also elsewhere on the board
il_sense-: C201.2, C202.1, NT701.1, Q203.3, Q204.3; also elsewhere on the board
pwr_enable: R205.2, R206.2; also elsewhere on the board
vn: C725.2, R213.2, R214.1; also elsewhere on the board
vp: C712.1, R211.2, R212.1; also elsewhere on the board

Notes on the sheet:
25V - 100V
-25V - -100V

Board: 4 copper layers, 140.0 x 100.0 mm, 311 parts (56 on the bottom side), 209 nets.

## Commit log

2018-05-22 Created KiCAD project for output driver
2018-05-24 Begun output stage schematic
2018-05-24 Output Driver Schematic
2018-05-25 Added Simulation of Inrush Current Limiter
2018-05-25 Inrush Current Limit
2018-05-26 .gitignore, Component Selection for Inrush Current Limiter
2018-05-27 Checked Transistor Power Dissipation
2018-05-27 Moved ICL to now Sheet
2018-06-01 Moved output stage to new schematic sheet
2018-06-01 Added bandwidth limitation in output driver
2018-06-04 Added Subsheets to structure Circuit
2018-06-04 Interface Wiring
2018-06-08 Added ADC Symbol, Started Wiring
2018-06-13 Added reference voltage circuit
2018-06-13 Added ADC Voltage Regulation and Reference Heater
2018-06-19 Added DAC, added disengage relay
2018-06-27 Improved Voltage Gain Stage
2018-06-27 Put opamp gain stage into schematic
2018-07-01 Removed Supply Sensing from vi_filter.sch
2018-07-02 Added Supply Schematic
2018-07-02 Added test points
2018-07-09 Added Page Titles
2018-07-09 Renamed Output Driver to Frontend
2018-07-12 Begun Filters
2018-07-15 Begun Range Switching Circuitry
2018-07-16 Finished Range Switching/Filters
2018-07-23 Changed to KiCAD 5
2018-07-23 Footrpints and Parts Specification
2018-07-24 Finished Footprints, ERC
2018-07-24 Fixed minor net issues, begun routing
2018-07-26 Begun routing
2018-08-26 Added switchable Gain for ADC Input Drivers
2018-08-31 A little more routing
2018-09-07 No Idea how markdown works
2018-09-07 More routing
2018-09-09 More routing (power supplies)
2018-09-16 More routing, fixed error in lockstep operation of current range switching relais
2018-09-17 Routing done
2018-09-28 Finished routing, begun component specification
2018-09-30 More Part Specifications added
2018-11-10 Some Updates from Testing
